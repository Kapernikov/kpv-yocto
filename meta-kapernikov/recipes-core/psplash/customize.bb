SUMMARY = "Kapernikov logo splash"
DESCRIPTION ="Custom splash image"
LICENSE = "MIT"

