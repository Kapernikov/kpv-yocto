
BUILDAH_VERSION = "1.36.0"

SRCREV_FORMAT = "buildah_storage"
SRCREV_buildah = "6ceba8838d331eb26378cb37d9fc8ba98939aa92"
SRCREV_storage = "246ba3062e8b551026aef2708eee747014ce5c52"

SRC_URI = " \
    git://github.com/containers/buildah;branch=release-1.36;name=buildah;protocol=https \
    "
