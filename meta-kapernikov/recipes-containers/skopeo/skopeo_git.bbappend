SRC_URI = " \
    git://github.com/containers/skopeo;branch=release-1.15;protocol=https;destsuffix=git/src/github.com/containers/skopeo \
    file://0001-makefile-add-GOBUILDFLAGS-to-go-build-call.patch \
"

SRCREV = "e2ea426918973e5e007a5e1e2457a41ab336fc41"
PV = "v1.15.1+git"
